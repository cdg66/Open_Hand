File: Open_hand/IMU.kicad_sch (KiCad schematic)
At the start: 4 parts, among them U10 ICM-40608

Commit message: update
Parts:
- renumbered C28 to C3, C29 to C4, C30 to C5, U10 to U4
